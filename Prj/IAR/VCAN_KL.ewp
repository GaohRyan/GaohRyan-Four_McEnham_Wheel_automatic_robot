# IAR project VCAN_KL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60FX512xxx15 Freescale MK60FX512xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: VCAN_KL.hex
  ILINK.IlinkOutputFile: VCAN_KL.out
  ILINK.IlinkIcfFile: config files\256KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL26Z256xxx4 Freescale MKL26Z256xxx4
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../../App/: ADcollect.c display.c initialize.c Keyscan.c main.c MKL_conf.c MKL_it.c motorcontrol.c parameterrw.c PID.c roadrecog.c servomotorcontrol.c upload.c
    ../../App/Inc/: MKL_conf.h PORT_cfg.h
  group Board
    ../../Board/Src/: LQ12864.c
  group Chip
    ../../Chip/Src/: misc.c MKL_adc.c MKL_dac.c MKL_dma.c MKL_flash.c MKL_gpio.c MKL_i2c.c MKL_lptmr.c MKL_mcg.c MKL_PIT.c MKL_port.c MKL_spi.c MKL_SysTick.c MKL_TPM.c MKL_uart.c MKL_wdog.c
    ../../Chip/Src/IAR/: startup_MKL.s system_MKL.c vectors.c
  group LIB/CMSIS
    ../../Lib/CMSIS/: iar_cortexM0plusl_math.a
